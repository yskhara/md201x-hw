# Repository yskhara/md201x-hw

## EAGLE design MD201x.brd

Parts:
C1, C2: CPOL-EUE5-10.5; E5-10,5
C3, C14, C15, C16, C17, C31: C-EUC0603; C0603
C4: CPOL-EUE2.5-5; E2,5-5
C5, C6, C7, C13: 100n/50V; C0603
C8: 100n; C0603
C9, C10: 100n/25V; C0603
C11, C12: 10u; C1210
D1, D4: BAS16W; SOD323-R
D2, D3, D5, D6: DIODE-SOD523; SOD523
H1, H2, H3, H4: MOUNT-HOLE3.2; 3,2
IC2: LM321MF; SOT23-5
Q1, Q2, Q3, Q4: N-MOSFET-; SOT669
R1, R2, R3, R4, R10, R11, R13, R14, R15, R16, R22, R23, R123: 10; R0603
R5, R6, R7, R8: 10k; R0603
R9, R19: 0.5m; CSS2H-2512
U5: NCP5106MN; SON80P400X400X100-11T275X300
U8: 7815DT; TO252
U$1: XT60PW-M
U$2: XT60PW-F
U$3: INA186DCK; SOT65P210X110-6
U$4: DGD05473FN; SON50P300X300X80-11T165X260

Connections:
0V: C5.2, C11.2, C12.2, R9.1, R19.1
3V3A: C15.2, IC2.5 (V+), R10.1, R15.1, U$3.3 (VS); also elsewhere on the board
+15V: C4.+, C7.1, C8.1, C13.1, D1.A, U5.1 (VCC), U8.2 (VO), U$4.1 (VCC); also elsewhere on the board
A_LS: Q2.1 (SOURCE), Q2.2 (SOURCE), Q2.3 (SOURCE), R7.1, R19.2
A_OUT: C9.2, Q1.1 (SOURCE), Q1.2 (SOURCE), Q1.3 (SOURCE), Q2.5 (DRAIN), R5.1, U5.6 (BRIDGE), U$2.POS
B_LS: C6.2, Q4.1 (SOURCE), Q4.2 (SOURCE), Q4.3 (SOURCE), R8.1, R9.2
B_OUT: C10.2, Q3.1 (SOURCE), Q3.2 (SOURCE), Q3.3 (SOURCE), Q4.5 (DRAIN), R6.1, U$2.NEG, U$4.5 (VS)
CS_OUT_A: U$3.6 (OUT)
CS_REF: U$3.1 (REF)
GNDA: C1.-, C2.-, C3.2, C4.-, C7.2, C8.2, C13.2, C14.1, C15.1, C16.1, C17.1, IC2.2 (V-), R11.2, R14.1, R16.2, U5.4 (GND), U8.3 (GND), U$1.NEG, U$1.P$1 (TAB), U$1.P$2 (TAB), U$2.P$1 (TAB), U$2.P$2 (TAB), U$3.2 (GND), U$4.9 (COM), U$4.11 (COM); also elsewhere on the board
IN_HI_A: U5.2 (IN_HI)
IN_HI_B: U$4.7 (HIN)
IN_LO_A: U5.3 (IN_LO)
IN_LO_B: U$4.8 (LIN)
ISENSE_B: C16.2, R123.1
unnamed: D6.C, R1.1, R5.2, U5.8 (DRV_HI)
unnamed: D2.C, R2.1, R6.2, U$4.4 (HO)
unnamed: D6.A, Q1.4 (GATE), R1.2
unnamed: D3.C, R4.1, R8.2, U$4.10 (LO)
unnamed: D5.C, R3.1, R7.2, U5.5 (DRV_LO)
unnamed: D2.A, Q3.4 (GATE), R2.2
unnamed: IC2.1 (+IN), R10.2, R11.1
unnamed: C31.2, R22.2, U$3.5 (IN-)
unnamed: C31.1, R23.2, U$3.4 (IN+)
unnamed: IC2.3 (-IN), IC2.4 (OUT)
unnamed: D5.A, Q2.4 (GATE), R3.2
unnamed: D3.A, Q4.4 (GATE), R4.2
unnamed: C10.1, U$4.3 (VB)
unnamed: C9.1, D1.C, U5.10 (VBOOT)
REF: C14.2, R15.2, R16.1
VCC: C1.+, C2.+, C3.1, C5.1, C6.1, C11.1, C12.1, Q1.5 (DRAIN), Q3.5 (DRAIN), R13.2, U8.1 (VI), U$1.POS
VCS_B_N: R9.1S, R22.1
VCS_B_P: R9.2S, R23.1
VSENSE: C17.2, R13.1, R14.2; also elsewhere on the board

Parts:
C21, C33, C34: 100n; C0603
C36: 100n; C1210
IC1: 78L05F; SOT89
J1: 8P8C-LED
J6: MA02-2; MA02-2W
Q5: BSS123; SOT23
R12: 120; R0603
R17, R28, R30: 1k; R0603
R18: 47k; R0603
R20: 4k7; R0603
R21: 470; R0603
U2: NCV7351D1E; SO08
U3: SI8621AB-B-IS; SO08
U4: TLP184; 11-4M1S

Connections:
5V_ISO: C33.2, C34.2, IC1.1 (VO), R17.2, U2.3 (VS), U2.5 (EN), U3.8 (VDD2)
!EMS: R30.2, U4.3 (E); also elsewhere on the board
!EMS_ISO: J1.6, R18.2, R28.2
+3V3: C21.2, U3.1 (VDD1), U4.4 (C); also elsewhere on the board
CANH: J1.1, U2.7 (CANH)
CANL: J1.2, U2.6 (CANL)
CANRX: U3.3 (A2); also elsewhere on the board
CANRX_ISO: U2.4 (RXD), U3.6 (B2)
CANTX: U3.2 (A1); also elsewhere on the board
CANTX_ISO: U2.1 (TXD), U3.7 (B1)
DC_ISO: C36.1, IC1.3 (VI), J1.4, J1.5, R20.1
GNDA: C21.1, J1.YC (C-Y), R30.1, U3.4 (GND1); also elsewhere on the board
GNDIO: C33.1, C34.1, C36.2, IC1.2 (GND), IC1.2@1 (GND), J1.3, J1.7, J1.8, J1.GC (C-G), J1.M1 (SHIELD), J1.M2 (SHIELD), J6.3, J6.4, Q5.2 (S), R18.1, U2.2 (GND), U2.8 (S), U3.5 (GND2)
LED_CAN: R21.1; also elsewhere on the board
unnamed: Q5.1 (G), R28.1
unnamed: J6.2, R12.2
unnamed: R17.1, U4.1 (AC1)
unnamed: Q5.3 (D), U4.2 (AC2)
unnamed: J1.GA (A-G), R20.2
unnamed: J1.YA (A-Y), R21.2

Notes on the sheet:
DFNのATA6560/1に変えたい

Parts:
B1: FERRITE_BEAD; R0603
C22, C24, C25, C26, C27, C28: 100n; C0603
C23: 4u7; C0805
C29: 10n; C0603
C30: 1u; C0603
CN1: S4B-XASK-1
CN2: S3B-XASK-1
D9, D10, D11: LEDCHIPLED_0805; CHIPLED_0805
J4: MA04-2; MA04-2W
J5: MA05-2; MA05-2W
R109, R110, R111: 1k; R0603
S1: SWITCH_TACTILETOP; SWITCH_TACTILE_3X6
U1: STM32F303C; LQFP48
U$5: MICRO-USB-RECEPTACLE47589-0001; 47589-0001
X1: CSTCE8M00G55

Connections:
3V3A: B1.1, C29.2, C30.2, U1.9 (VDDA-VREF+); also elsewhere on the board
!EMS: U1.2 (PC13-TAMPER-RTC); also elsewhere on the board
!RESET: C22.2, S1.P$2 (2), U1.7 (NRST)
+3V3: B1.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, J4.8, U1.24 (VDD$1), U1.36 (VDD$2), U1.48 (VDD$3); also elsewhere on the board
+5V: J4.5; also elsewhere on the board
BOOT0: U1.44 (BOOT0)
CANRX: U1.45 (PB8); also elsewhere on the board
CANTX: U1.46 (PB9); also elsewhere on the board
ENC_A: U1.42 (PB6)
ENC_B: U1.43 (PB7)
GNDA: C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, D9.C, D10.C, D11.C, J4.2, J4.7, J5.2, J5.4, J5.6, J5.8, J5.10, S1.P$1 (1), U1.8 (VSSA-VREF-), U1.23 (VSS$1), U1.35 (VSS$2), U1.47 (VSS$3), X1.2; also elsewhere on the board
IN_A: U1.12 (PA2)
IN_B: U1.13 (PA3)
IN_HI_A_PRE: U1.30 (PA9)
IN_HI_B_PRE: U1.29 (PA8)
ISENSE: U1.14 (PA4)
JMP0: J5.9, U1.19 (PB1)
JMP1: J5.7, U1.20 (PB2)
JMP2: J5.5, U1.21 (PB10)
JMP3: J5.3, U1.22 (PB11)
JMP4: J5.1, U1.25 (PB12)
LED0: R109.1, U1.16 (PA6)
LED1: R110.1, U1.17 (PA7)
LED2: R111.1, U1.18 (PB0)
LED_CAN: U1.3 (PC14-OSC32_IN); also elsewhere on the board
unnamed: D10.A, R110.2
unnamed: D9.A, R109.2
unnamed: U1.6 (PF1-OSC_OUT), X1.3
unnamed: U1.5 (PF0-OSC_IN), X1.1
unnamed: D11.A, R111.2
SWCLK: J4.4, U1.37 (PA14-JTCK-SWCLK)
SWDIO: J4.6, U1.34 (PA13-JTMS-SWDIO)
UART_RX: J4.1
UART_TX: J4.3
USB_DM: U1.32 (PA11)
USB_DP: U1.33 (PA12)
VSENSE: U1.15 (PA5); also elsewhere on the board

Notes on the sheet:
TODO: BOOT0をジャンパで切り替えられるようにする
TODO: デバッガ用コネクタを最適化する
TODO: エンコーダ入力を5Vトレラントにする エンコーダ入力にLPF入れる
TODO: PWM信号を直列終端する

Parts:
C18: 22u; E2,5-5
C19, C20: 100n; C0603
U9: 7805DT; TO252
U10: XC6206; SOT95P240X110-3

Connections:
+3V3: C20.1, U10.2 (VOUT); also elsewhere on the board
+5V: C18.+, C19.1, U9.2 (VO), U10.3 (VIN); also elsewhere on the board
+15V: U9.1 (VI); also elsewhere on the board
GNDA: C18.-, C19.2, C20.2, U9.3 (GND), U10.1 (VSS); also elsewhere on the board

Board: 4 copper layers, 100.0 x 50.0 mm, 105 parts (49 on the bottom side), 64 nets.

## Commit log

2019-07-17 first commit; add brd/sch files
2019-08-19 add panelized stuff
2019-08-19 add panelized from 19-Mar-24
2019-08-21 staging everything i have right now
2019-08-25 stage everything
2019-12-03 change: board size to 50x100, back-to-back MOSFETs
2019-12-11 still in progress...
2020-02-14 add din bracket via upload

Notices in the files:
parts and their libraries:
con-molex-usb: (C) 2014 Tomasz Boleslaw CEDRO, cederom@tlen.pl, http://www.tomek.cedro.info.
